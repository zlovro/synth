<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\synth-h743vit6-makefile.ewp</path>
  </project>
  <batchBuild />
</workspace>
